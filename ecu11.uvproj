# Keil uVision project ecu11.uvproj, settings and files
target ecu11 (ARM-ADS)
  device: LPC11C14/301 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10001FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: ecu11 +hex
  c flags: Optim=1
  c define: CORTEX _DBGOUT _LPC1100_
  c include: .\
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group StartUp
    ./: startup_LPC11xx.s system_LPC11xx.c
  group src
    ./: can.c leds.c event.c uart.c printf.c buttons.c
  group main
    ./: ecu.c
target ecu11 (release) (ARM-ADS)
  device: LPC11C14/301 NXP (founded by Philips)
  cpu: as above
  output: ecu11_rel +hex
  c flags: Optim=3
  c define: CORTEX _LPC1100_ RELEASE
  c include: .\
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
